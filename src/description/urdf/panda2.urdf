Commit message: panda 2 moveit config

File: src/description/urdf/panda2.urdf (robot description, URDF)
Before this commit: robot panda2, 12 links, 11 joints
Joints:
- joint panda2_joint_world: origin xyz=1.5 0 rpy=0 0 3.14159 -> xyz=0 0 0 rpy=0 0 0
